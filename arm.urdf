Commit message: Updates

File: arm.urdf (robot description, URDF)
Before this commit: robot zebra_zero, 8 links, 7 joints
Joints:
- joint base_joint: origin xyz=0 0 0 rpy=0 1.57 -1.57 -> xyz=0 0 0 rpy=-1.57 0 0
- joint second_joint: origin xyz=0 0 0.4 rpy=0 0 0 -> xyz=0 0 0.25 rpy=0 0 0
